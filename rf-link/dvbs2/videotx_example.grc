options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: Video TXRX Example
  states: {}

blocks:
- name: cc_encoder
  id: variable_cc_encoder_def
  parameters:
    framebits: '10576'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: constellation_0
  id: variable_constellation
  parameters:
    precision: '8'
    type: 8psk
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '1316'
  states: {}
- name: samp_per_symb
  id: variable
  parameters:
    value: int(samp_rate/symb_rate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(3e6)
  states: {}
- name: symb_rate
  id: variable
  parameters:
    value: 750e3
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/charles/tiny-compressed.ts
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    limit: time
    maximum: '.01'
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation_0
    differential: 'True'
    excess_bw: '0.35'
    log: 'True'
    samples_per_symbol: samp_per_symb
    verbose: 'True'
  states: {}
- name: digital_crc_append_1
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {state: bypassed}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport struct\n\nclass blk(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name='Custom PDU Header Prepend',\n            in_sig=None,\n            out_sig=None\n        )\n        self.message_port_register_in(pmt.intern('in-pdu'))\n        self.message_port_register_out(pmt.intern('out-pdu'))\n        self.set_msg_handler(pmt.intern('in-pdu'), self.handle_msg)\n\n    def handle_msg(self, msg):\n        # Get the payload from the input PDU\n        payload = bytes(pmt.u8vector_elements(pmt.cdr(msg)))\n        payload_len = len(payload)\n\n        # 1. Create 4-byte sync word\n        sync_word = b'\\x1A\\xCF\\xFC\\x1D'\n\n        # 2. Create 2-byte length field (Big-Endian Unsigned Short)\n        #    The '!H' format string is crucial here.\n        length_field = struct.pack('!H', payload_len)\n\n        # 3. Prepend header to the original payload\n        new_payload_bytes = sync_word + length_field + payload\n        \n        # 4. Create a new PDU with the new payload\n        new_pdu = pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(len(new_payload_bytes), list(new_payload_bytes)))\n        \n        # 5. Send the new PDU to the output port\n        self.message_port_pub(pmt.intern('out-pdu'), new_pdu)\n\n"
  states: {}
- name: fec_generic_encoder_0
  id: fec_generic_encoder
  parameters:
    encoder: cc_encoder
    itype: byte
    otype: byte
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: samp_rate
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(915e6)
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: packet_len
    port: '1234'
    src_zeros: 'False'
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    depth: '2000'
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    gain: '1'
    interp: samp_per_symb
    ntaps: '12'
    samp_rate: samp_rate
    sym_rate: symb_rate
    type: interp_fir_filter_ccf
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle2_0, '0', digital_scrambler_bb_0, '0']
- [digital_constellation_modulator_0, '0', root_raised_cosine_filter_0, '0']
- [digital_crc_append_1, out, epy_block_0, in-pdu]
- [digital_scrambler_bb_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [epy_block_0, out-pdu, pdu_pdu_to_stream_x_0, pdus]
- [fec_generic_encoder_0, '0', digital_constellation_modulator_0, '0']
- [pdu_pdu_to_stream_x_0, '0', fec_generic_encoder_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc_append_1, in]
- [root_raised_cosine_filter_0, '0', iio_pluto_sink_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_const_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
