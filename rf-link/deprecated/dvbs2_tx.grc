options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dvbs2_tx
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 2.5e9
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: taps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '50'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: adv.cfile
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/charles/tablesaw-trim.ts
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /tmp/tsfifo
    repeat: 'False'
    type: byte
  states: {}
- name: dtv_dvb_bbheader_bb_0
  id: dtv_dvb_bbheader_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    rolloff: RO_0_20
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bbscrambler_bb_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C1_2
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvbs2_interleaver_bb_0
  id: dtv_dvbs2_interleaver_bb
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    rate1: C1_2
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C1_2
  states: {}
- name: dtv_dvbs2_physical_cc_0
  id: dtv_dvbs2_physical_cc
  parameters:
    constellation: MOD_QPSK
    framesize: FECFRAME_NORMAL
    goldcode: '0'
    pilots: PILOTS_ON
    rate1: C1_2
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(1, samp_rate, samp_rate/2, rolloff, taps)
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(center_freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {state: disabled}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1316'
    port: '2000'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'True'
    payloadsize: '1316'
    port: '5000'
    src_zeros: 'True'
    type: byte
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_custom_sink_0
  id: soapy_custom_sink
  parameters:
    bandwidth0: '6000000'
    center_freq0: center_freq
    gain0: tx_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_hackrf_sink_1
  id: soapy_hackrf_sink
  parameters:
    center_freq: center_freq
    dev_args: serial=000000000000000060a464dc3674640f
    samp_rate: samp_rate
    type: fc32
    vga: '0'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(center_freq, ((symbol_rate * (1 + rolloff)) / 2 ) + 1e5)
    clock_rate: '0.0'
    dev_addr: '"send_frame_size=8192,num_send_frames=256,master_clock_rate=" + str(samp_rate*4)'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ldpc-int
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: mod-phy
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ldpc-int
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: mod-phy
  states: {}

connections:
- [blocks_file_source_1, '0', dtv_dvb_bbheader_bb_0, '0']
- [dtv_dvb_bbheader_bb_0, '0', dtv_dvb_bbscrambler_bb_0, '0']
- [dtv_dvb_bbscrambler_bb_0, '0', dtv_dvb_bch_bb_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', virtual_sink_0, '0']
- [dtv_dvbs2_interleaver_bb_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', virtual_sink_1, '0']
- [dtv_dvbs2_physical_cc_0, '0', fft_filter_xxx_0, '0']
- [fft_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [fft_filter_xxx_0, '0', iio_pluto_sink_0, '0']
- [fft_filter_xxx_0, '0', network_udp_sink_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fft_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [fft_filter_xxx_0, '0', soapy_custom_sink_0, '0']
- [fft_filter_xxx_0, '0', soapy_hackrf_sink_1, '0']
- [fft_filter_xxx_0, '0', uhd_usrp_sink_0_0, '0']
- [network_udp_source_0, '0', dtv_dvb_bbheader_bb_0, '0']
- [virtual_source_0, '0', dtv_dvbs2_interleaver_bb_0, '0']
- [virtual_source_1, '0', dtv_dvbs2_physical_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
